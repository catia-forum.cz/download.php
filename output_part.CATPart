# CATIA V5 part "output_part.CATPart"
Saved by CATIA V5R19 SP2, build 10-23-2008
Part number: output_part
Stored file links:
  D:\Catia\Makra\test_maker\output_part.CATPart
  D:\Catia\Makra\test_maker\input_part.CATPart
  D:\Catia\Makra\test_maker\create_ccp_link.CATProduct

## Design history (mm, degrees; sets first, then bodies; in a sketch O, H, V are its origin and axes)
AxisSystem1: origin (0, 0, 0), X (1, 0, 0), Y (0, 1, 0), Z (0, 0, 1)
Body1 (main body)